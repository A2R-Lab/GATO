Commit message: add time-varying disturbance example

File: examples/indy7_description/indy7.urdf (robot description, URDF)
Before this commit: robot indy, 9 links, 8 joints
Joints:
- removed joint tcp
- added joint EE: type fixed, parent link6, child tcp, origin xyz=0 0 0.06 rpy=0 0 0
